# Repository zycero/AiPocket-Kicad-ESP32-P4-seconde

File README.md:

# AiPocket-Kicad-ESP32-P4-seconde

## KiCad design AI_Pocket.kicad_pcb

Parts:
C1, C3: 10uF/16V; C_0603_1608Metric; MPN GRM188R61E106KA73D; LCSC C344022
C2, C4, C5, C6, C9, C10, C11, C12, C14, C17, C22, C24, C25, C28, C29, C32: 100nF/16V; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C7, C8: 15pF; C_0402_1005Metric; MPN 0402CG150J500NT; LCSC C1548
C13, C18, C23, C27, C30, C31, C33, C34: 1uF/16V; C_0402_1005Metric; MPN CL05A105KA5NQNC; LCSC C52923
C15, C20: 100nF/16V; C_0402_1005Metric; Voltage 16V; MPN CL05B104KO5NNNC; LCSC C1525
C16, C21: 10nF/50V; C_0402_1005Metric; MPN CL05B103KB5NNNC; LCSC C15195
C19: 1uF/16V; C_0402_1005Metric; Voltage 16V; MPN CL05A105KA5NQNC; LCSC C52923
C26: 10uF/10V; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
D1, D4: D_TVS; D_0402_1005Metric; MPN 0402ESDA-05N; LCSC C316049
D2: Red; LED_0603_1608Metric; MPN KT-0603R; LCSC C2286
D3: Green; LED_0603_1608Metric; MPN XL-1608UGC-04; LCSC C965804
R1, R2, R5, R8: 10K/1%; R_0402_1005Metric; MPN AC0402FR-0710KL; LCSC C144807
R3, R4: 4.02K/1%; R_0402_1005Metric; MPN RC0402FR-074K02L; LCSC C137968
R6, R7: 2.2K/1%; R_0402_1005Metric; MPN FRC0402F2201TS; LCSC C2906865
SW1: Reset; SW_SPST_TS-1088-xR020; MPN TS-1088-AR02016; LCSC C720477
SW2: Boot; SW_SPST_TS-1088-xR020; MPN TS-1088-AR02016; LCSC C720477
TP6: GPIO47; TestPoint_Pad_D1.0mm
TP7: GPIO0-ADC; TestPoint_Pad_D1.0mm
U1: PY25Q128HA-WXH-IR; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm; MPN PY25Q128HA-WXH-IR; LCSC C18208279
U2: ESP32-P4NRW32; ESP32-P4; MPN ESP32-P4NRW32; LCSC C22387510
Y1: Q22FA12800332; Crystal_SMD_2016-4Pin_2.0x1.6mm; MPN Q22FA12800332; LCSC C255899

Connections:
BOOT: D4.2 (A2), R8.1, SW2.1, U2.66 (GPIO35)
C6_EN: U2.98 (GPIO54/ADC); also elsewhere on the board
C6_WAKEUP: U2.6 (GPIO6/ADC); also elsewhere on the board
DSI_CLK_N: U2.37 (DSI_CLKN); also elsewhere on the board
DSI_CLK_P: U2.38 (DSI_CLKP); also elsewhere on the board
DSI_D0_N: U2.40 (DSI_DATAN0); also elsewhere on the board
DSI_D0_P: U2.39 (DSI_DATAP0); also elsewhere on the board
DSI_D1_N: U2.36 (DSI_DATAN1); also elsewhere on the board
DSI_D1_P: U2.35 (DSI_DATAP1); also elsewhere on the board
EN_DCDC: U2.79 (EN_DCDC); also elsewhere on the board
ESP_3V3: C1.1, C2.1, C4.1, C5.1, C9.1, C11.1, C21.1, C22.1, C23.1, C25.2, C26.2, C28.2, C32.2, R2.1, R5.1, R6.1, R8.2, U2.9 (VDD_LP), U2.21 (VDD_IO_0), U2.51 (VDD_USBPHY), U2.62 (VDD_IO_4), U2.75 (VDD_LDO), U2.77 (VDD_DCDCC), U2.96 (VDD_IO_6), U2.101 (VDD_ANA), U2.102 (VDD_BAT); also elsewhere on the board
ESP_LDO_VO1: C10.1, C13.1, C14.1, C33.2, C34.2, R1.1, U1.8 (VCC), U2.30 (VDD_FLASH_IO), U2.71 (VDDO_FLASH)
ESP_LDO_VO2: C24.2, C31.2, U2.59 (VDD_PSRAM_0), U2.67 (VDD_PSRAM_1), U2.72 (VDDO_PSRAM)
ESP_LDO_VO3: C16.1, C17.1, C18.1, C30.2, U2.41 (VDD_MIPI_DPHY), U2.73 (VDDO_3)
ESP_LDO_VO4: C19.1, C20.1, C27.2, U2.74 (VDDO_4), U2.85 (VDD_IO_5)
ESP_SCL: U2.7 (GPIO7/ADC); also elsewhere on the board
ESP_SDA: U2.8 (GPIO8/ADC); also elsewhere on the board
ESP_VDD_HP: C3.1, C6.1, C15.1, C29.2, U2.26 (VDD_HP_0), U2.76 (VDD_HP_2), U2.91 (VDD_HP_3); also elsewhere on the board
FB_DCDC: U2.78 (FB_DCDC); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, D1.1 (A1), D2.1 (K), D3.1 (K), D4.1 (A1), R3.2, R4.2, SW1.2, SW2.2, U1.4 (GND), U1.9 (EP), U2.105 (GND), Y1.2 (G), Y1.4 (G); also elsewhere on the board
GPIO_VIB: U2.55 (GPIO26/ADC/USB); also elsewhere on the board
I2S_BCLK: U2.2 (GPIO2/ADC); also elsewhere on the board
I2S_CLK: U2.92 (GPIO49/ADC); also elsewhere on the board
I2S_DATA: U2.93 (GPIO50/ADC); also elsewhere on the board
I2S_DOUT: U2.1 (GPIO1/ADC); also elsewhere on the board
I2S_LRCLK: U2.13 (GPIO12/ADC); also elsewhere on the board
KEY_DET: U2.11 (GPIO10/ADC); also elsewhere on the board
LCD_BL_PWM: U2.23 (GPIO21/ADC); also elsewhere on the board
LCD_RESET: U2.56 (GPIO27/ADC/USB); also elsewhere on the board
unnamed: D2.2 (A), R6.2
unnamed: D3.2 (A), R7.2
unnamed: U1.6 (CLK), U2.32 (FLASH_CK)
unnamed: U1.5 (DI/IO_{0}), U2.33 (FLASH_D)
unnamed: U1.2 (DO/IO_{1}), U2.28 (FLASH_Q)
unnamed: R1.2, U1.1 (~CS), U2.27 (FLASH_CS)
unnamed: U1.7 (~HOLD/~RESET/IO_{3}), U2.31 (FLASH_HOLD)
unnamed: U1.3 (~WP/IO_{2}), U2.29 (FLASH_WP)
unnamed: R4.1, U2.48 (CSI_REXT)
unnamed: R3.1, U2.34 (DSI_REXT)
unnamed: TP7.1 (1_1), U2.104 (GPIO0/ADC)
unnamed: R5.2, U2.68 (GPIO36)
unnamed: TP6.1 (1_1), U2.89 (GPIO47)
unnamed: C7.2, U2.99 (XTAL_N), Y1.1
unnamed: C8.2, U2.100 (XTAL_P), Y1.3
RESET: C12.1, D1.2 (A2), R2.2, SW1.1, U2.103 (CHIP_PU)
SD1_CLK: U2.60 (GPIO30); also elsewhere on the board
SD1_CMD: U2.58 (GPIO29); also elsewhere on the board
SD1_D0: U2.61 (GPIO31); also elsewhere on the board
SD1_D1: U2.63 (GPIO32); also elsewhere on the board
SD1_D2: U2.64 (GPIO33); also elsewhere on the board
SD1_D3: U2.57 (GPIO28); also elsewhere on the board
SD1_PWRN: U2.87 (GPIO45); also elsewhere on the board
SDIO_CLK: U2.81 (GPIO40); also elsewhere on the board
SDIO_CMD: U2.80 (GPIO39); also elsewhere on the board
SDIO_D0: U2.82 (GPIO41); also elsewhere on the board
SDIO_D1: U2.83 (GPIO42); also elsewhere on the board
SDIO_D2: U2.84 (GPIO43); also elsewhere on the board
SDIO_D3: U2.86 (GPIO44); also elsewhere on the board
SOUND_EN: U2.14 (GPIO13/ADC); also elsewhere on the board
SYS_HOLD: U2.12 (GPIO11/ADC); also elsewhere on the board
TP_INT: U2.16 (GPIO15/ADC); also elsewhere on the board
TP_RESET: U2.25 (GPIO23/ADC); also elsewhere on the board
USB1_N: U2.52 (GPIO24/ADC/USB); also elsewhere on the board
USB1_P: U2.53 (GPIO25/ADC/USB); also elsewhere on the board
User_LED: R7.1, U2.3 (GPIO3/ADC)

Notes on the sheet:
VO4 = 3.3V VO3 = 2.5V VO2 = 1.8V VO1 = 3.3V

Parts:
C35: 10uF/10V; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
C36, C37, C38: 100nF/16V; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
J1: Conn_01x40; Hirose_FH12-40S-0.5SH_1x40-1MP_P0.50mm_Horizontal; MPN AFC07-S40ECA-00; LCSC C262648
R9, R10: 2.2K/1%; R_0402_1005Metric; MPN FRC0402F2201TS; LCSC C2906865
R47, R48: 10K/1%; R_0402_1005Metric; MPN AC0402FR-0710KL; LCSC C144807

Connections:
DSI_CLK_N: J1.17; also elsewhere on the board
DSI_CLK_P: J1.16; also elsewhere on the board
DSI_D0_N: J1.11; also elsewhere on the board
DSI_D0_P: J1.10; also elsewhere on the board
DSI_D1_N: J1.14; also elsewhere on the board
DSI_D1_P: J1.13; also elsewhere on the board
ESP_3V3: C35.2, C36.2, C37.2, C38.2, J1.25, J1.26, J1.27, J1.28, J1.39, R9.1, R10.1, R47.2; also elsewhere on the board
ESP_SCL: J1.37, R10.2; also elsewhere on the board
ESP_SDA: J1.36, R9.2; also elsewhere on the board
GND: C35.1, C36.1, C37.1, C38.1, J1.9, J1.12, J1.15, J1.18, J1.19, J1.20, J1.21, J1.22, J1.23, J1.24, J1.29, J1.32, J1.33, J1.38, R48.2; also elsewhere on the board
LCD_RESET: J1.31; also elsewhere on the board
LEDA: J1.6, J1.7; also elsewhere on the board
LEDK: J1.1, J1.2; also elsewhere on the board
TP_INT: J1.35, R48.1; also elsewhere on the board
TP_RESET: J1.34, R47.1; also elsewhere on the board

Parts:
D8: B5819W; D_SOD-123; MPN B5819W SL; LCSC C8598
J4: Conn_01x02; SolderWirePad_1x02_SMD_0.8x1.2mm_P1.4mm
Q1: AO3400A; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; MPN AO3400A; LCSC C20917
R19: 1K; R_0402_1005Metric; MPN FRC0402F1001TS; LCSC C2906864
R20: 10K/1%; R_0402_1005Metric; MPN AC0402FR-0710KL; LCSC C144807

Connections:
/VIB/-VIB: D8.2 (+), J4.1, Q1.3 (D)
ESP_3V3: D8.1 (-), J4.2; also elsewhere on the board
GND: Q1.2 (S), R20.1; also elsewhere on the board
GPIO_VIB: R19.1; also elsewhere on the board
unnamed: Q1.1 (G), R19.2, R20.2

Parts:
C47: 10uF/16V; C_0603_1608Metric; MPN GRM188R61E106KA73D; LCSC C344022
C48: 100nF/16V; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
D9, D10, D11, D12, D13, D14, D15: D_TVS; D_0402_1005Metric; MPN 0402ESDA-05N; LCSC C316049
J5: SD_Card_Device; microSD_HC_Hirose_DM3D-SF; MPN DM3D-SF; LCSC C719027
Q2: AO3401; SOT-23; MPN AO3401A; LCSC C15127
R21, R22, R24, R25, R26: 10K/1%; R_0402_1005Metric; MPN AC0402FR-0710KL; LCSC C144807
R23: 0R/1%; R_0402_1005Metric; MPN RC0402FR-070RL; LCSC C106231
R27: 51K/1%; R_0402_1005Metric; MPN 0402WGF5102TCE; LCSC C25794

Connections:
ESP_3V3: Q2.2 (S); also elsewhere on the board
GND: C47.2, C48.2, D9.2 (A2), D10.2 (A2), D11.2 (A2), D12.2 (A2), D13.2 (A2), D14.2 (A2), D15.2 (A2), J5.3 (VSS), J5.6 (VSS), R27.2; also elsewhere on the board
unnamed: D13.1 (A1), J5.5 (CLK), R23.2
unnamed: C47.1, C48.1, D15.1 (A1), J5.4 (VDD), Q2.3 (D), R21.2, R22.2, R24.2, R25.2, R26.2
SD1_CLK: R23.1; also elsewhere on the board
SD1_CMD: D14.1 (A1), J5.2 (CMD), R26.1; also elsewhere on the board
SD1_D0: D9.1 (A1), J5.7 (DAT0), R21.1; also elsewhere on the board
SD1_D1: D10.1 (A1), J5.8 (DAT1), R22.1; also elsewhere on the board
SD1_D2: D11.1 (A1), J5.9 (DAT2), R24.1; also elsewhere on the board
SD1_D3: D12.1 (A1), J5.1 (CD/DAT3), R25.1; also elsewhere on the board
SD1_PWRN: Q2.1 (G), R27.1; also elsewhere on the board

Parts:
C44: 100nF/16V; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C45: 1uF/16V; C_0402_1005Metric; MPN CL05A105KA5NQNC; LCSC C52923
C46: 10uF/10V; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
J3: Conn_01x02; SolderWirePad_1x02_SMD_0.8x1.2mm_P1.4mm
R18: 100K; R_0402_1005Metric; MPN FRC0402F1003TS; LCSC C2906859
U4: NS4168_C910588; ESOP-8_L4.9-W3.9-P1.27-LS6.0-BL-EP; MPN NS4168; LCSC C910588

Connections:
/Sound/+Sound: J3.2, U4.5 (VON)
/Sound/-Sound: J3.1, U4.8 (VOP)
ESP_3V3: C44.1, C45.1, C46.1, U4.6 (VDD); also elsewhere on the board
GND: C44.2, C45.2, C46.2, R18.1, U4.7 (GND), U4.9 (EP); also elsewhere on the board
I2S_BCLK: U4.3 (BCLK); also elsewhere on the board
I2S_DOUT: U4.4 (SDATA); also elsewhere on the board
I2S_LRCLK: U4.2 (LRCLK); also elsewhere on the board
SOUND_EN: R18.2, U4.1 (CTRL); also elsewhere on the board

Parts:
C39, C40: 10uF/10V; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
C41: 1uF/16V; C_0402_1005Metric; MPN CL05A105KA5NQNC; LCSC C52923
C42: 22uF; C_0805_2012Metric; MPN CGA0805X5R226M250MT; LCSC C6119899
C43: 1nF/2KV; C_1206_3216Metric; MPN 1206B102K202NT; LCSC C9196
D5, D6, D7: D_TVS; D_0402_1005Metric; MPN 0402ESDA-05N; LCSC C316049
F1: Polyfuse; Fuse_1206_3216Metric; MPN ASMD1206-200; LCSC C135342
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12; MPN TYPE-C-31-M-12; LCSC C165948
J7: Conn_01x02; SolderWirePad_1x02_SMD_1.5x3mm_P2.5mm
L1: 2.2uH; L_1210_3225Metric; MPN FTC322510S2R2MBCA; LCSC C18724399
R11, R12: 5.1K/1%; R_0402_1005Metric; MPN 0402WGF5101TCE; LCSC C25905
R13, R14: 4.7k; R_0402_1005Metric; MPN RC0402FR-074K7L; LCSC C105871
R15, R16: 22R/1%; R_0402_1005Metric; MPN RC0402FR-0722RL; LCSC C114765
R17: 1M/1%; R_0402_1005Metric; MPN 0402WGF1004TCE; LCSC C26083
U3: ETA6003; QFN-16-1EP_3x3mm_P0.5mm_EP1.75x1.75mm_ThermalVias; MPN ETA6003Q3Q; LCSC C5455585

Connections:
GND: C40.1, C41.1, C42.1, C43.2, D5.1 (A1), D6.1 (A1), D7.1 (A1), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J7.1, R11.2, R12.2, R13.2, R14.2, R17.2, U3.6 (ENB), U3.7 (NTC), U3.8 (ENPPB), U3.10 (GND), U3.13 (USB_DET), U3.17 (EP); also elsewhere on the board
unnamed: D5.2 (A2), F1.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
unnamed: D6.2 (A2), J2.A6 (D+), J2.B6 (D+), R16.1
unnamed: D7.2 (A2), J2.A7 (D-), J2.B7 (D-), R15.1
unnamed: J2.A5 (CC1), R11.1
unnamed: J2.B5 (CC2), R12.1
unnamed: C41.2, J7.2, U3.14 (BATT), U3.16 (BATT)
unnamed: L1.2, U3.3 (SW), U3.4 (SW)
unnamed: R13.1, U3.11 (ISET1)
unnamed: R14.1, U3.12 (ISET2)
unnamed: C39.2, U3.5 (PGND)
PGND: C43.1, J2.SH (SHIELD), R17.1
USB1_N: R15.2; also elsewhere on the board
USB1_P: R16.2; also elsewhere on the board
VSYS: C42.2, L1.1, U3.1 (SYS), U3.15 (SYS); also elsewhere on the board
VUSB: C39.1, C40.2, F1.2, U3.2 (IN)

Parts:
C51, C53: 100nF/16V; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C52: 10uF/10V; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
J6: Conn_01x05; SolderWirePad_1x05_SMD_0.8x1.2mm_P1.6mm
R28, R29, R30, R31, R32, R33, R34, R35, R36: 10K/1%; R_0402_1005Metric; MPN AC0402FR-0710KL; LCSC C144807
U5: ESP32-C6-MINI-1; MPN ESP32-C6-MINI-1-N4; LCSC C5736265

Connections:
/ESP32_C6/C6_BOOT: J6.4, R30.2, U5.23 (IO9)
/ESP32_C6/C6_RX0: J6.3, U5.30 (RXD0)
/ESP32_C6/C6_TX0: J6.2, U5.31 (TXD0)
C6_EN: C51.1, J6.5, R28.2, U5.8 (EN); also elsewhere on the board
C6_WAKEUP: U5.5 (IO2); also elsewhere on the board
ESP_3V3: C52.2, C53.2, R28.1, R29.1, R30.1, R31.2, R33.2, R34.2, R35.2, R36.2, U5.3 (3V3); also elsewhere on the board
GND: C51.2, C52.1, C53.1, J6.1, R32.2, U5.1 (GND), U5.2 (GND), U5.11 (GND), U5.14 (GND), U5.36 (GND), U5.37 (GND), U5.38 (GND), U5.39 (GND), U5.40 (GND), U5.41 (GND), U5.42 (GND), U5.43 (GND), U5.44 (GND), U5.45 (GND), U5.46 (GND), U5.47 (GND), U5.48 (GND), U5.49 (GND), U5.50 (GND), U5.51 (GND), U5.52 (GND), U5.53 (GND); also elsewhere on the board
unnamed: R29.2, U5.22 (IO8)
unnamed: R32.1, U5.20 (IO15)
SDIO_CLK: U5.25 (IO19); also elsewhere on the board
SDIO_CMD: R36.1, U5.24 (IO18); also elsewhere on the board
SDIO_D0: R35.1, U5.26 (IO20); also elsewhere on the board
SDIO_D1: R34.1, U5.27 (IO21); also elsewhere on the board
SDIO_D2: R33.1, U5.28 (IO22); also elsewhere on the board
SDIO_D3: R31.1, U5.29 (IO23); also elsewhere on the board

Parts:
C49: 10uF/10V; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
C50: 100nF/16V; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
MK1: MSM261DGT003; MIC-SMD_6P-L4.0-W2.0_LMD4020T261-OC3; MPN MSM261DGT003; LCSC C48227730
TP4: I2S_CLK; TestPoint_Pad_D1.0mm
TP5: I2S_DATA; TestPoint_Pad_D1.0mm

Connections:
ESP_3V3: C49.2, C50.2, MK1.1 (VDD); also elsewhere on the board
GND: C49.1, C50.1, MK1.2 (GND), MK1.5 (GND), MK1.6 (L/R); also elsewhere on the board
I2S_CLK: MK1.4 (CLK), TP4.1 (1_1); also elsewhere on the board
I2S_DATA: MK1.3 (DATA), TP5.1 (1_1); also elsewhere on the board

Schematic: Power_1V1.kicad_sch

Parts:
C54, C55: 10uF/10V; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
L2: 2.2uH; L_1210_3225Metric; MPN FTC322510S2R2MBCA; LCSC C18724399
R37: 1M/1%; R_0402_1005Metric; MPN 0402WGF1004TCE; LCSC C26083
R49, R50: 10K/1%; R_0402_1005Metric; MPN AC0402FR-0710KL; LCSC C144807
TP3: 1V1; TestPoint_Pad_D1.0mm
U6: SY8089AAAC; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; MPN SY8089AAAC; LCSC C78988

Connections:
EN_DCDC: R37.1, U6.1 (EN); also elsewhere on the board
ESP_3V3: C54.1, U6.4 (IN); also elsewhere on the board
ESP_VDD_HP: C55.1, L2.2, R49.2, TP3.1 (1_1); also elsewhere on the board
FB_DCDC: R49.1, R50.1, U6.5 (FB); also elsewhere on the board
GND: C54.2, C55.2, R37.2, R50.2, U6.2 (GND); also elsewhere on the board
unnamed: L2.1, U6.3 (LX)

Notes on the sheet:
DCDC 1.1V 输出

Schematic: LCD_Power.kicad_sch

Parts:
C56: 100nF/16V; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C57: 4.7uF/16V; C_0603_1608Metric; MPN CL10A475KO8NNNC; LCSC C19666
C58: 2.2uF/50V; C_1206_3216Metric; MPN CL31B225KBHNNNE; LCSC C50254
D16: B5819W; D_SOD-123; MPN B5819W SL; LCSC C8598
J8: Conn_01x02; SolderWirePad_1x02_SMD_0.8x1.2mm_P1.4mm
L3: 22uH; L_1210_3225Metric; MPN FTC322520S220MBCA; LCSC C53281638
R38: 7.5R; R_0402_1005Metric; MPN 0402WGF7R50TCE; LCSC C137751
R39: 1M/1%; R_0402_1005Metric; MPN 0402WGF1004TCE; LCSC C26083
U7: SY7301AADC; TSOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR; MPN SY7301AADC; LCSC C160791

Connections:
GND: C56.1, C57.1, C58.1, R38.2, R39.1, U7.2 (GND); also elsewhere on the board
LCD_BL_PWM: R39.2, U7.4 (EN/PWM); also elsewhere on the board
LEDA: C58.2, D16.1 (K), J8.1, U7.5 (OVP); also elsewhere on the board
LEDK: J8.2, R38.1, U7.3 (FB); also elsewhere on the board
unnamed: D16.2 (A), L3.1, U7.1 (LX)
VSYS: C56.2, C57.2, L3.2, U7.6 (IN); also elsewhere on the board

Schematic: Power_3V3.kicad_sch

Parts:
C59, C60, C61: 10uF/10V; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
D17, D18: BAT54; D_SOD-123; MPN BAT54T1G; LCSC C152458
L4: 2.2uH; L_1210_3225Metric; MPN FTC322510S2R2MBCA; LCSC C18724399
R40, R41, R43: 100K; R_0402_1005Metric; MPN FRC0402F1003TS; LCSC C2906859
R42: 30K; R_0402_1005Metric; MPN FRC0402F3002TS; LCSC C2909347
R44: 10K/1%; R_0402_1005Metric; MPN AC0402FR-0710KL; LCSC C144807
R45: 30.1K; R_0402_1005Metric; MPN 0402WGF3012TCE; LCSC C25901
R46: 6.65K; R_0402_1005Metric; MPN 0402WGF6651TCE; LCSC C45194
SW3: PWR_KEY; SW-SMD_2P-TS24CA; MPN TS24CA; LCSC C393942
TP1: 3V3; TestPoint_Pad_D1.0mm
TP2: GND; TestPoint_Pad_D1.0mm
U8: SY8089AAAC; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; MPN SY8089AAAC; LCSC C78988

Connections:
/Power/Power_3V3/MAIN_EN: C60.2, D17.1 (K), R43.1, R44.1, U8.1 (EN)
ESP_3V3: C61.1, L4.2, R45.2, TP1.1 (1_1); also elsewhere on the board
GND: C59.2, C60.1, C61.2, R40.1, R42.1, R43.2, R46.2, TP2.1 (1_1), U8.2 (GND); also elsewhere on the board
KEY_DET: R41.2, R42.2; also elsewhere on the board
unnamed: D17.2 (A), R40.2, R41.1, SW3.2
unnamed: D18.1 (K), R44.2
unnamed: R45.1, R46.1, U8.5 (FB)
unnamed: L4.1, U8.3 (LX)
SYS_HOLD: D18.2 (A); also elsewhere on the board
VSYS: C59.1, SW3.1, U8.4 (IN); also elsewhere on the board

Notes on the sheet:
DCDC 3.3V 输出
